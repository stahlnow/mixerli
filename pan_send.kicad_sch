File: pan_send.kicad_sch (KiCad schematic)
At the start: 22 parts

Commit message: update LICENSE
Other:
- company: (none) -> stahllabs
- title: (none) -> mixerli
